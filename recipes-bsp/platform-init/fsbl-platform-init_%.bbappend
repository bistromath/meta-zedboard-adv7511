BOARD_NAME_zedboard-zynq7-adv7511 = "zed"
